# Keil uVision project project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c misc: -Wno-unused-value -Wno-macro-redefined
  c include: .\Start;.\library;.\user;.\System\Sys;.\System\delay;.\System\I2C;.\System\USART;.\Hardware\LED;.\Hardware\KEY;.\Hardware\MPU6050;.\Hardware\MPU6050\eMPL;.\Hardware\IMU;.\NNoM;.\NNoM\nnom_lib\inc;.\NNoM\nnom_lib\inc\layers;.\NNoM\nnom_lib\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: system_stm32f10x.c startup_stm32f10x_md.s system_stm32f10x.h core_cm3.h stm32f10x.h
  group Library
    ./library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ./System/Sys/: Sys.c
    ./System/delay/: delay.c
    ./System/I2C/: I2CSoftware.c
    ./System/USART/: USART1.c
  group User
    ./user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h CyberMagicWand.c Model.c
  group Hardware
    ./Hardware/LED/: LED.c
    ./Hardware/MPU6050/: MPU6050.c
    ./Hardware/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Hardware/IMU/: IMU.c
    ./Hardware/KEY/: KeyStateMachine.c
  group NNoM
    ./NNoM/nnom_lib/src/backends/: nnom_local.c nnom_local_q15.c
    ./NNoM/nnom_lib/src/core/: nnom.c nnom_layers.c nnom_tensor.c nnom_utils.c
    ./NNoM/nnom_lib/src/layers/: nnom_activation.c nnom_avgpool.c nnom_baselayer.c nnom_concat.c nnom_conv2d.c nnom_conv2d_trans.c nnom_cropping.c nnom_dense.c nnom_dw_conv2d.c nnom_flatten.c nnom_global_pool.c nnom_gru_cell.c nnom_input.c nnom_lambda.c nnom_lstm_cell.c nnom_matrix.c nnom_maxpool.c nnom_output.c nnom_reshape.c nnom_rnn.c nnom_simple_cell.c nnom_softmax.c nnom_sumpool.c nnom_upsample.c nnom_zero_padding.c
